# Keil uVision project project.uvprojx, settings and files
target 键盘 (5060960::V5.06 update 7 for Certification (build 960)::.\ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F10x\Include;..\Firmware\GD32F10x_standard_peripheral\Include;..\Hardware;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ../Doc/: readme.txt
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
    ../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Firmware
    ../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_gpio.c gd32f10x_rcu.c gd32f10x_usart.c gd32f10x_adc.c gd32f10x_timer.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_wwdgt.c
  group Hardware
    ../Hardware/: usart.c OLED.c OLED.h oledfont.h Delay.c Delay.h PWM.c PWM.h Key.c Key.h ADC.c ADC.h Menu.c Menu.h IIC.c IIC.h AS5600.c AS5600.h FOC.c FOC.h Fast_sin.h GPIO.c GPIO.h W25QXX.c W25QXX.h W25QXX_ins.h SPI.c SPI.h Timer.c Timer.h PID_Speed.c PID_Speed.h PID_Angle.c PID_Angle.h PID_I.c PID_I.h
  group User
    ../User/: gd32f10x_it.c main.c systick.c main.h
